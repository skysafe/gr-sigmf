options:
  parameters:
    generate_options: no_gui
    id: usrp_gps
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2.45e9
  states: {}
- name: gain
  id: variable
  parameters:
    value: '15'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: uhd_args
  id: variable
  parameters:
    value: '''addr=192.168.40.2'''
  states: {}
- name: sigmf_sink_0
  id: sigmf_sink
  parameters:
    append: 'False'
    author: ''
    debug: 'False'
    description: USRP GPS SigMF Example
    field_10_key: ''
    field_10_type: string
    field_10_value: ''
    field_11_key: ''
    field_11_type: string
    field_11_value: ''
    field_12_key: ''
    field_12_type: string
    field_12_value: ''
    field_13_key: ''
    field_13_type: string
    field_13_value: ''
    field_14_key: ''
    field_14_type: string
    field_14_value: ''
    field_15_key: ''
    field_15_type: string
    field_15_value: ''
    field_16_key: ''
    field_16_type: string
    field_16_value: ''
    field_17_key: ''
    field_17_type: string
    field_17_value: ''
    field_18_key: ''
    field_18_type: string
    field_18_value: ''
    field_19_key: ''
    field_19_type: string
    field_19_value: ''
    field_1_key: ''
    field_1_type: string
    field_1_value: ''
    field_20_key: ''
    field_20_type: string
    field_20_value: ''
    field_21_key: ''
    field_21_type: string
    field_21_value: ''
    field_22_key: ''
    field_22_type: string
    field_22_value: ''
    field_23_key: ''
    field_23_type: string
    field_23_value: ''
    field_24_key: ''
    field_24_type: string
    field_24_value: ''
    field_25_key: ''
    field_25_type: string
    field_25_value: ''
    field_2_key: ''
    field_2_type: string
    field_2_value: ''
    field_3_key: ''
    field_3_type: string
    field_3_value: ''
    field_4_key: ''
    field_4_type: string
    field_4_value: ''
    field_5_key: ''
    field_5_type: string
    field_5_value: ''
    field_6_key: ''
    field_6_type: string
    field_6_value: ''
    field_7_key: ''
    field_7_type: string
    field_7_value: ''
    field_8_key: ''
    field_8_type: string
    field_8_value: ''
    field_9_key: ''
    field_9_type: string
    field_9_value: ''
    filename: /tmp/usrp-gps.sigmf-meta
    hardware: USRP
    license: WTFPL
    num_extra_fields: '0'
    samp_rate: samp_rate
    time_mode: sigmf.sigmf_time_mode_absolute
    type: fc32
  states: {}
- name: sigmf_usrp_gps_message_source_0
  id: sigmf_usrp_gps_message_source
  parameters:
    poll_interval: '1.0'
    uhd_args: uhd_args
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: freq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: uhd_args
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [sigmf_usrp_gps_message_source_0, out, sigmf_sink_0, gps]
- [uhd_usrp_source_0, '0', sigmf_sink_0, '0']

metadata:
  file_format: 1
